# Keil uVision project test_FIR_DMA_IT.uvprojx, settings and files
target test_FIR_DMA_IT (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32G474RETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.1.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: test_FIR_DMA_IT +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32G474xx,USE_NUCLEO_64
  c include: ../Inc;            C:/Users/zulolo/STM32Cube/Repository/STM32Cube_FW_G4_V1.2.0/Drivers/STM32G4xx_HAL_Driver/Inc;            C:/Users/zulolo/STM32Cube/Repository/STM32Cube_FW_G4_V1.2.0/Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;            C:/Users/zulolo/STM32Cube/Repository/STM32Cube_FW_G4_V1.2.0/Drivers/CMSIS/Device/ST/STM32G4xx/Include;            C:/Users/zulolo/STM32Cube/Repository/STM32Cube_FW_G4_V1.2.0/Drivers/CMSIS/Include;            C:\Users\zulolo\STM32Cube\Repository\STM32Cube_FW_G4_V1.2.0\Drivers\BSP\STM32G4xx_Nucleo
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32g474xx.s
  group Application/User
    ../Src/: main.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Drivers/STM32G4xx_HAL_Driver
    C:/Users/zulolo/STM32Cube/Repository/STM32Cube_FW_G4_V1.2.0/Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_gpio.c stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_dac.c stm32g4xx_hal_dac_ex.c stm32g4xx_hal_fmac.c stm32g4xx_hal_opamp.c stm32g4xx_hal_opamp_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_ll_pwr.c
  group Drivers/CMSIS
    ../Src/: system_stm32g4xx.c
  group Drivers/BSP/STM32G4xx_Nucleo
    ../Src/: stm32g4xx_nucleo.c
software components: CMSIS:CORE 5.3.0
